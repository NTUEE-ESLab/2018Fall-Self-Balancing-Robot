# Keil uVision project EasyBalance.uvproj, settings and files
target EasyBalance (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: EasyBalance +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Common;.\Driver;.\User
  group Driver
    ./Driver/: DELAY.c IAP.c PWM.c TIMER.c UART.c
  group Common
    ./Common/: I2C.c LED.c MPU6050.c NOKIA5110.c OUTPUTDATA.c
  group User
    ./User/: ISR.c MAIN.c UpstandingCar.c
  group Startup
    ./Startup/: STARTUP.A51
